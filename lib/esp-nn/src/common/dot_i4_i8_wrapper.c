// SPDX-FileCopyrightText: 2026 RecursiveIntell
// SPDX-License-Identifier: MIT
//
// int4 x int8 dot product for ESP32-S3.
// Unpacks a small tile of packed signed int4 weights into aligned int8 scratch,
// then reuses the proven ESP-NN s8 SIMD dot kernel. This avoids the custom
// ACCX/Q-register bug seen in the first hand-written i4 assembly attempt.

#include <stdint.h>
#include <stddef.h>
#include "esp_attr.h"

DRAM_ATTR static const uint16_t I4_PAIR_LUT[256] = {
    0x0000, 0x0001, 0x0002, 0x0003, 0x0004, 0x0005, 0x0006, 0x0007,
    0x00f8, 0x00f9, 0x00fa, 0x00fb, 0x00fc, 0x00fd, 0x00fe, 0x00ff,
    0x0100, 0x0101, 0x0102, 0x0103, 0x0104, 0x0105, 0x0106, 0x0107,
    0x01f8, 0x01f9, 0x01fa, 0x01fb, 0x01fc, 0x01fd, 0x01fe, 0x01ff,
    0x0200, 0x0201, 0x0202, 0x0203, 0x0204, 0x0205, 0x0206, 0x0207,
    0x02f8, 0x02f9, 0x02fa, 0x02fb, 0x02fc, 0x02fd, 0x02fe, 0x02ff,
    0x0300, 0x0301, 0x0302, 0x0303, 0x0304, 0x0305, 0x0306, 0x0307,
    0x03f8, 0x03f9, 0x03fa, 0x03fb, 0x03fc, 0x03fd, 0x03fe, 0x03ff,
    0x0400, 0x0401, 0x0402, 0x0403, 0x0404, 0x0405, 0x0406, 0x0407,
    0x04f8, 0x04f9, 0x04fa, 0x04fb, 0x04fc, 0x04fd, 0x04fe, 0x04ff,
    0x0500, 0x0501, 0x0502, 0x0503, 0x0504, 0x0505, 0x0506, 0x0507,
    0x05f8, 0x05f9, 0x05fa, 0x05fb, 0x05fc, 0x05fd, 0x05fe, 0x05ff,
    0x0600, 0x0601, 0x0602, 0x0603, 0x0604, 0x0605, 0x0606, 0x0607,
    0x06f8, 0x06f9, 0x06fa, 0x06fb, 0x06fc, 0x06fd, 0x06fe, 0x06ff,
    0x0700, 0x0701, 0x0702, 0x0703, 0x0704, 0x0705, 0x0706, 0x0707,
    0x07f8, 0x07f9, 0x07fa, 0x07fb, 0x07fc, 0x07fd, 0x07fe, 0x07ff,
    0xf800, 0xf801, 0xf802, 0xf803, 0xf804, 0xf805, 0xf806, 0xf807,
    0xf8f8, 0xf8f9, 0xf8fa, 0xf8fb, 0xf8fc, 0xf8fd, 0xf8fe, 0xf8ff,
    0xf900, 0xf901, 0xf902, 0xf903, 0xf904, 0xf905, 0xf906, 0xf907,
    0xf9f8, 0xf9f9, 0xf9fa, 0xf9fb, 0xf9fc, 0xf9fd, 0xf9fe, 0xf9ff,
    0xfa00, 0xfa01, 0xfa02, 0xfa03, 0xfa04, 0xfa05, 0xfa06, 0xfa07,
    0xfaf8, 0xfaf9, 0xfafa, 0xfafb, 0xfafc, 0xfafd, 0xfafe, 0xfaff,
    0xfb00, 0xfb01, 0xfb02, 0xfb03, 0xfb04, 0xfb05, 0xfb06, 0xfb07,
    0xfbf8, 0xfbf9, 0xfbfa, 0xfbfb, 0xfbfc, 0xfbfd, 0xfbfe, 0xfbff,
    0xfc00, 0xfc01, 0xfc02, 0xfc03, 0xfc04, 0xfc05, 0xfc06, 0xfc07,
    0xfcf8, 0xfcf9, 0xfcfa, 0xfcfb, 0xfcfc, 0xfcfd, 0xfcfe, 0xfcff,
    0xfd00, 0xfd01, 0xfd02, 0xfd03, 0xfd04, 0xfd05, 0xfd06, 0xfd07,
    0xfdf8, 0xfdf9, 0xfdfa, 0xfdfb, 0xfdfc, 0xfdfd, 0xfdfe, 0xfdff,
    0xfe00, 0xfe01, 0xfe02, 0xfe03, 0xfe04, 0xfe05, 0xfe06, 0xfe07,
    0xfef8, 0xfef9, 0xfefa, 0xfefb, 0xfefc, 0xfefd, 0xfefe, 0xfeff,
    0xff00, 0xff01, 0xff02, 0xff03, 0xff04, 0xff05, 0xff06, 0xff07,
    0xfff8, 0xfff9, 0xfffa, 0xfffb, 0xfffc, 0xfffd, 0xfffe, 0xffff,
};

extern int32_t dot_i4_i8_simd_esp32s3(const int8_t *input_data,
                                       const int8_t *filter_data,
                                       int32_t len_div16);

static inline int8_t i4_to_i8_signed(uint8_t nibble) {
    int8_t v = (int8_t)(nibble & 0x0F);
    return (v & 8) ? (int8_t)(v | 0xF0) : v;
}

int32_t dot_i4_i8_fast_esp32s3(const int8_t *input,
                                const uint8_t *weights_packed,
                                int n) {
    int32_t result = 0;
    int blocks = n >> 4;
    int rem = n & 15;
    int offset = 0;

    // Local stack scratch eliminates cross-core races. 256 bytes is small enough
    // for the existing core0 worker task and loop task stacks, and 16-byte aligned
    // for ESP-NN SIMD loads.
    int8_t scratch[256] __attribute__((aligned(16)));

    while (blocks > 0) {
        int blocks_this = (blocks > 16) ? 16 : blocks;
        int elems_this = blocks_this << 4;

        uint16_t *scratch2 = (uint16_t *)scratch;
        const uint8_t *wp = weights_packed + (offset >> 1);
        for (int i = 0; i < (elems_this >> 1); i++) {
            scratch2[i] = I4_PAIR_LUT[wp[i]];
        }

        result += dot_i4_i8_simd_esp32s3(input + offset, scratch, blocks_this);
        offset += elems_this;
        blocks -= blocks_this;
    }

    for (int i = 0; i < rem; i++) {
        int idx = offset + i;
        uint8_t b = weights_packed[idx >> 1];
        int8_t w = (idx & 1) ? i4_to_i8_signed(b >> 4) : i4_to_i8_signed(b);
        result += (int32_t)w * (int32_t)input[idx];
    }

    return result;
}
